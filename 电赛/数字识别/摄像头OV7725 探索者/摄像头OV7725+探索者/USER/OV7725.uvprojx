# Keil uVision project OV7725.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OV7670 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\HARDWARE\DCMI;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\USART2;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\SRAM;..\HARDWARE\OV7670;..\COLOR;..\HARDWARE\OV7725\OV7725;..\HARDWARE\CONTROL;..\HARDWARE\SDIO;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/CONTROL/: control.c
    ../HARDWARE/OV7725/OV7725/: ov7725.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/STMFLASH/: stmflash.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_flash.c
  group COCLOR
    ../COLOR/: color.c
