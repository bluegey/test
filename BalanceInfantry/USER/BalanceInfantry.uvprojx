# Keil uVision project BalanceInfantry.uvprojx, settings and files
target BalanceInfantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4, __FPU_PRESENT
  c misc: --C99 --CPP11
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\Apply\PID;..\HARDWARE\CAN;..\Apply\CanReceive;..\Apply\Remote;..\Filter;..\Task\MpuTask;..\Task\StartTask;..\Task\ChassisTask;..\Apply\MotorControl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c main.cpp
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/CAN/: can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_i2c.c stm32f4xx_spi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group Apply
    ../Apply/PID/: PID.cpp
    ../Apply/CanReceive/: CanReceive.cpp
    ../Apply/Remote/: RemoteControl.cpp
    ../Apply/MotorControl/: MotorControl.cpp
  group Filter
    ../Filter/: IIR_Filter.c Smooth_Filter.c
  group Task
    ../Task/StartTask/: Start.cpp
    ../Task/MpuTask/: Mputask.cpp Matrix.c IMU.cpp
    $TC_ROOT$/../../Users/xiang/Desktop/git/BalanceInfantry/Task/MpuTask/: arm_cortexM4lf_math.lib
    ../Task/ChassisTask/: ChassisTask.cpp
