# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\OLED;..\TASK\Motor_Task;..\TASK\Start_Task;..\HARDWARE\KEY;..\TASK\OLED_Task;..\HARDWARE\OLED;..\HARDWARE\OLED;..\HARDWARE\EXIT;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\HARDWARE\CAN;..\Math\PID;..\HARDWARE\CAN_DATE;..\HARDWARE\Infrared_remote;..\HARDWARE\PWM;..\HARDWARE\DUBS_RC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EXIT/: Exit.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/CAN_DATE/: Can_Receive.c
    ../HARDWARE/Infrared_remote/: remote.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/DUBS_RC/: RC.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
  group TASK
    ../TASK/Motor_Task/: Motor_Task.c
    ../TASK/OLED_Task/: OLED_Task.c
    ../TASK/Start_Task/: Start_Task.c
  group Math
    ../Math/PID/: pid.c
