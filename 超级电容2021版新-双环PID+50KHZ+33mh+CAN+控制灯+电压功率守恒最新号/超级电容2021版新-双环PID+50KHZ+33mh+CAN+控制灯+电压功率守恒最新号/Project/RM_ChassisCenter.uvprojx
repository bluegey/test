# Keil uVision project RM_ChassisCenter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RM_ChassisCenter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --diag_suppress 3731
  c include: ..\Task;..\Main;..\BSP;..\RMlib;..\IMU;..\IMU\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ../Main/: main.c mydelay.c init.c PID_Control.c
  group Bsp_Init
    ../BSP/: BSP_CAN_Init.c BSP_USART_Init.c BSP_GPIO_Init.c INA260_Driver.c BSP_IIC_Init.c BSP_SuperCapacitor_Init.c BSP_ADC_Init.c
  group Task
    ../Task/: CAN_Task.c Judge_Task.c Monitor_Task.c PowerSupply_Task.c
    ../RMlib/: judgement_info.c
  group RMLib
    ../RMlib/: protocol.c
  group IMU
    ../IMU/: mpuiic.c mpu6050.c mpu6050_interrupt.c
    ../IMU/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX5 5.2.3, CMSIS:RTOS2:Keil RTX5 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
