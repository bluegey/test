# Keil uVision project user.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: user
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\PROJECT;..\CODE;..\STM32f10x_FWLIB\inc;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\Devicer;..\system\delay;..\system\sys;..\system\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MAIN
    ./: system_stm32f10x.c stm32f10x_it.c main.c init.c
  group CODE
    ../CODE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32f10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Devicer
    ../Devicer/: devicer_can.c devicer_remote.c devicer_usart.c devicer_adc.c devicer_led.c devicer_pwm.c devicer_pid.c
  group SYSTEM
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
